Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowTerminal: DP7504:DP7504, DP7504:DP7504:1094542
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 120 mm; Height: 380 mm; Width: 97 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_86:Toilet brush holders; CodePerformance: n/a; Color: Brush Satin or PolishedDP7504PSS; Constituents: n/a; Description: Toilet brush holder; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brush Satin or PolishedDP7504PSS; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: "DP7504; ModelReference: DolphinSolutionsLimited_ToiletBrushHolder; Name: ToiletBrushHolder_DP7504_DolphinSolutionsLimited; NBSDescription: Toilet brush holders; NBSReference: 45-35-72/364; NBSTypeID: n/a; NominalHeight: 380; NominalLength: 129; NominalWidth: 97; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-toilet-brush-set-dp7504/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 97 x 380 x 129 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DP7504; Uniclass2015Code: Pr_40_20_76_86; Uniclass2015Title: Toilet brush holders; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DP7504
Type - Pset_ElementShading - Color: Brush Satin or PolishedDP7504PSS
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletBrushHolder; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ToiletBrushHolder_DP7504_DolphinSolutionsLimited; Category: Pr_40_20_76_86:Toilet brush holders
Pset_DistributionFlowElementCommon - Reference: DP7504:DP7504; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 102 mm; Host: Level : Level 0; Offset from Host: 102 mm
Dimensions - Area: 0.0495552 m2; Volume: 0.000163583 m3
Identity Data - Mark: 824
Other - Family: DP7504: DP7504; Family and Type: DP7504: DP7504; Type: DP7504: DP7504; Type Id: DP7504: DP7504
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DS213.150.150:DS213.150.150, DS213.150.150:DS213.150.150:1094552
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 125 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; BodyIngressProtectionMinimum: IP68 connector; Category: Pr_40_20_87_98:Washbasin Taps; CodePerformance: WRAS; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: InformBasinTap; DurationUnit: year; ElectricalSupplyFrequency: 50/ 60 Hz; ElectricalSupplyRatedOperationalVoltage: Plug in 9v Transformers 100-240V; ExpectedLife: n/a; Features: Up to 70% water savings_BREEAM/ SKA/ LEED/ WELL/ WRAS/ compliant_Flow rate: Max. 3.0 litres/minute between 0.5 and 6.0 bar_Water supply: single inlet cold or pre-mixed � a TMV2 or TMV3 thermostatic mixing valve is recommended for premixed application; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Form: CounterMounted; Grade: 316; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DS213.150.150; ModelReference: DolphinSolutionsLimited_InformBsainTap; Name: WashBasinTaps_Inform_BasinTap_DS213.150.150_DolphinSolutionsLimited; NBSDescription: WashbasinTaps; NBSReference: 45-35-70/371; NBSTypeID: n/a; NominalHeight: 150 mm; NominalLength: 150 mm; NominalWidth: 22 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.55.17; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-inform-basin-tap-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 150 x 150 x 22 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DS213.150.150; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin Taps; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DS213.150.150
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_InformBsainTap; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WashBasinTaps_Inform_BasinTap_DS213.150.150_DolphinSolutionsLimited; Category: Pr_40_20_87_98:Washbasin Taps
Pset_DistributionFlowElementCommon - Reference: DS213.150.150:DS213.150.150; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 720 mm; Host: Level : Level 0; Offset from Host: 720 mm
Dimensions - Area: 0.0207593 m2; Volume: 0.0000445686 m3
Identity Data - Mark: 834
Other - AL0220: yes; Family: DS213.150.150: DS213.150.150; Family and Type: DS213.150.150: DS213.150.150; Type: DS213.150.150: DS213.150.150; Type Id: DS213.150.150: DS213.150.150
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC754:BC754, BC754:BC754:1094546
In: Level 0
Type - Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 200 mm; Height: 50 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_78:Shelves; CAWS: N13/449 Shelves; CodePerformance: n/a; Color: Brushed Satin_RAL Colours; Constituents: n/a; Description: Shelf; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin_PowderCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: Shelf; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC754; ModelReference: DolphinSolutionsLimited_Shelf; Name: Shelves_Shelf_BC754_DolphinSolutionsLimited; NBSDescription: Shelves; NBSReference: 45-35-80/320; NBSTypeID: n/a; NominalHeight: 50; NominalLength: 400; NominalWidth: 200; ObjectClassification: 23.40.20.27.11; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.11; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 200 x 400 x 50 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC754; Uniclass2015Code: Pr_40_30_78_78; Uniclass2015Title: Shelves; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC754
Type - Pset_ElementShading - Color: Brushed Satin_RAL Colours
Type - Pset_FurnitureTypeCommon - Description: Shelf; NominalHeight: 15240 mm; NominalLength: 121920 mm
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Shelf; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Shelves_Shelf_BC754_DolphinSolutionsLimited; Category: Pr_40_30_78_78:Shelves
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC754:BC754
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 710 mm; Host: Level : Level 0; Offset from Host: 710 mm
Dimensions - Area: 0.126358 m2; Volume: 0.000250292 m3
Identity Data - Mark: 828
Other - Family: BC754: BC754; Family and Type: BC754: BC754; Type: BC754: BC754; Type Id: BC754: BC754
Phasing - Phase Created: New Construction
